FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-rsa-with-black-keys-curve25519-ecdh.patch"

